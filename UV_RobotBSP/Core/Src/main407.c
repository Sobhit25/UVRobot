#include "main407.h"
#include "MPU9250.h"
#include "stdio.h"
#include "PID.h"

I2C_HandleTypeDef hi2c2;

UART_HandleTypeDef huart2;

void SystemClock_Config(void);
void I2C2_Init(void);
void USART2_UART_Init(void);

int main(void){

  HAL_Init();

  SystemClock_Config();

  I2C2_Init();

  USART2_UART_Init();

  while (1)
  {

	  MPU9250_t mpu9250;
	  mpu9250.accel_range = ACCEL_FS_SEL_2G;
	  mpu9250.gyro_range = GYRO_FS_SEL_250DPS;
	  mpu9250.dlpf_bandwidth = GYRO_DLPF_250;

	  uint8_t check = 0;
	  HAL_I2C_Mem_Read(&hi2c2, 0xD0, 0x75, 1, &check, 1, HAL_MAX_DELAY);
	  printf("Lets see if its working...\n");
	  fflush(stdout);
	  HAL_Delay(1000);

	  if(check == 0x71){
		  printf("Wonderful connection established\n");
		  fflush(stdout);
		  HAL_Delay(1000);

		  MPU9250_Initialisation(&mpu9250, &hi2c2);
		  printf("MPU Initialisation Complete\n");
		  fflush(stdout);
		  HAL_Delay(1000);

		  //Let get some gyro values
		  printf("Let get some gyro values:-\n");
		  fflush(stdout);
		  HAL_Delay(1000);

		  while(1){
			  Get_Raw_Gyro(&mpu9250, &hi2c2);
			  printf("Gyro_X = %u  Gyro_Y = %u  Gyro_Z = %u\n", mpu9250.Acc_X_RAW, mpu9250.Acc_Y_RAW, mpu9250.Acc_Z_RAW);
			  fflush(stdout);
			  HAL_Delay(1000);
		  }

	  }

  }
  return 0;
}

void SystemClock_Config(void)
{

}

void I2C2_Init(void)
{
  hi2c2.Instance = I2C2;
  hi2c2.Init.ClockSpeed = 400000;
  hi2c2.Init.DutyCycle = I2C_DUTYCYCLE_2;
  hi2c2.Init.OwnAddress1 = 0;
  hi2c2.Init.AddressingMode = I2C_ADDRESSINGMODE_7BIT;
  hi2c2.Init.DualAddressMode = I2C_DUALADDRESS_DISABLE;
  hi2c2.Init.OwnAddress2 = 0;
  hi2c2.Init.GeneralCallMode = I2C_GENERALCALL_DISABLE;
  hi2c2.Init.NoStretchMode = I2C_NOSTRETCH_DISABLE;
  if (HAL_I2C_Init(&hi2c2) != HAL_OK)
  {
    Error_Handler();
  }


}


void USART2_UART_Init(void)
{

  huart2.Instance = USART2;
  huart2.Init.BaudRate = 115200;
  huart2.Init.WordLength = UART_WORDLENGTH_8B;
  huart2.Init.StopBits = UART_STOPBITS_1;
  huart2.Init.Parity = UART_PARITY_NONE;
  huart2.Init.Mode = UART_MODE_TX_RX;
  huart2.Init.HwFlowCtl = UART_HWCONTROL_NONE;
  huart2.Init.OverSampling = UART_OVERSAMPLING_16;
  if (HAL_UART_Init(&huart2) != HAL_OK)
  {
    Error_Handler();
  }


}

void Error_Handler(void){

}
